# IAR project loadcell_feeder.ewp, settings and files
configuration loadcell_feeder (ARM, debug)
  General.OGChipSelectEditMenu: STM32F410RB ST STM32F410RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F410Rx
  ICCARM.CCIncludePath2: ../Inc; ../Src; ..\..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\STM32Cube_FW_F4\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: loadcell_feeder.out
  ILINK.IlinkIcfFile: stm32f410rx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f410rx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../STM32Cube/Repository/STM32Cube_FW_F4_V1.21.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
    ../../STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c
